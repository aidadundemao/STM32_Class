# Keil uVision project ProjLed.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ProjLed +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SysLib\CORE;..\SysLib\STDV35_LIB\inc;..\SysLib\SYSTEM;.\hardware;..\SysLib\SYSTEM\delay;..\SysLib\SYSTEM\sys;.\hardware;..\SysLib\SYSTEM\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./hardware/: main.c led.c exit.c exit.h stm32f10x_it.c
    ../SysLib/SYSTEM/delay/: mydelay.c
  group CORE
    ../SysLib/CORE/: core_cm3.c startup_stm32f10x_hd.s
    ../SysLib/SYSTEM/: system_stm32f10x.c
  group STDV35LIB
    ../SysLib/STDV35_LIB/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c
